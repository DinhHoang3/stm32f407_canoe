# Keil uVision project project_3.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project_3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User_Driver\can;.\User_Driver\uart;.\User_Driver\gpio;.\User_Driver\rcc;.\User_Driver\timer;.\User_Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User_App
    ./User_App/: main.c
  group User_Driver
    ./User_Driver/uart/: uart_config.c uart_config.h
    ./User_Driver/timer/: timer_config.c timer_config.h
    ./User_Driver/rcc/: rcc_config.c rcc_config.h
    ./User_Driver/gpio/: gpio_config.c gpio_config.h
    ./User_Driver/can/: can_config.c can_config.h
    ./User_Driver/: general_type.h stub.h stub.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
